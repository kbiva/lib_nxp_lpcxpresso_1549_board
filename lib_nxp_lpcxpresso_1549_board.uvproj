# Keil uVision project lib_nxp_lpcxpresso_1549_board.uvproj, settings and files
target lib_nxp_lpcxpresso_1549_board (ARM-ADS)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x02000000,0x9000) CPUTYPE("Cortex-M3") CLOCK(75000000) ELITTLE
  output: lib_nxp_lpcxpresso_1549_board (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: .\inc;..\lib_lpc_chip_15xx\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group inc
    ./inc/: board.h
  group src
    ./src/: board.c board_sysinit.c
